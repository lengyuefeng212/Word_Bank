# Keil uVision project luatao.uvprojx, settings and files
target Target 1 (ARM-ADS)
  device: STM32F103ZE STMicroelectronics
  pack: Keil.STM32F1xx_DFP.1.0.5
  cpu: IROM(0x08000000,0x80000) IRAM(0x20000000,0x10000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: luatao +hex
  c flags: Optim=1 OneElfS=1 uC99=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER
  c include: .\Libraries\CMSIS;.\User;.\Libraries\STM32F10x_StdPeriph_Driver\inc;.\App;.\Head;.\Public
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group User
    ./User/: stm32f10x_it.c main.c
  group StartUp
    ./Libraries/CMSIS/: startup_stm32f10x_hd.s
  group peripheral
    ./Libraries/STM32F10x_StdPeriph_Driver/src/: stm32f10x_rcc.c stm32f10x_gpio.c stm32f10x_usart.c stm32f10x_tim.c stm32f10x_spi.c
  group CMSIS
    ./Libraries/CMSIS/: core_cm3.c system_stm32f10x.c
    ./Libraries/STM32F10x_StdPeriph_Driver/src/: misc.c
  group App
    ./App/: LED.c USART1.c key.c command.c bsp_spi_flash.c
  group Head
    ./Head/: All.h
  group Public
    ./Public/: System.c SysTick.c
